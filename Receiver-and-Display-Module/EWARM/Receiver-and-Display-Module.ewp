# IAR project Receiver-and-Display-Module.ewp, settings and files
configuration Receiver-and-Display-Module (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083RC ST STM32U083RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_NUCLEO_64; USE_HAL_DRIVER; STM32U083xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../Drivers/BSP/STM32U0xx_Nucleo; ../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../Drivers/CMSIS/Include; ..\TouchGFX\App; ..\TouchGFX\target\generated; ..\TouchGFX\target; ../Middlewares/ST/touchgfx/framework/include; ..\TouchGFX\generated\fonts\include; ..\TouchGFX\generated\gui_generated\include; ..\TouchGFX\generated\images\include; ..\TouchGFX\generated\texts\include; ..\TouchGFX\generated\videos\include; ..\TouchGFX\gui\include; ..\Middlewares\X-CUBE-SUBG2\App; ..\Middlewares\X-CUBE-SUBG2\Target; ..\Drivers\CMSIS\Device\ST\STM32U0xx\Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/custom; ..\Drivers\BSP\X-NUCLEO-S2868A2; ../Drivers/BSP/Components/S2LP; ../Drivers/BSP/Components/S2LP/S2LP_Library/inc; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/videos/include; ../TouchGFX/gui/include; ..\Core\Inc\TouchGFXDesigner; ..\TouchGFX\generated\images\include\images
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Receiver-and-Display-Module.hex
  ILINK.IlinkOutputFile: Receiver-and-Display-Module.out
  ILINK.IlinkIcfFile: stm32u083xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u083xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u0xx_hal_msp.c stm32u0xx_it.c
  group Application/User/Core/TouchGFXDesigner
    ../Core/Src/TouchGFXDesigner/: custom_bus.c MB1642ButtonController.cpp MB1642DataReader.c MB1642DisplayDriver.c update_data.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/S2LP/: s2lp.c
    ../Drivers/BSP/Components/S2LP/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/custom
    ../Drivers/BSP/custom/: custom.c
  group Drivers/BSP/X-NUCLEO-S2868A2
    ../Drivers/BSP/X-NUCLEO-S2868A2/: s2868a2.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_crc.c stm32u0xx_hal_crc_ex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Middlewares/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Middlewares/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_11_4bpp_0.cpp Font_verdana_25_4bpp_0.cpp Font_verdanab_24_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_11_4bpp.cpp Kerning_verdana_25_4bpp.cpp Kerning_verdanab_24_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_11_4bpp.cpp Table_verdana_25_4bpp.cpp Table_verdanab_24_4bpp.cpp UnmappedDataFont.cpp VectorFontRendererBuffers.cpp
  group Middlewares/TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/receiver_display_screen/: Receiver_displayViewBase.cpp
  group Middlewares/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp image_background.cpp SVGDatabase.cpp
  group Middlewares/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Middlewares/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Middlewares/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Middlewares/TouchGFX/gui/receiver_display_screen
    ../TouchGFX/gui/src/receiver_display_screen/: Receiver_displayPresenter.cpp Receiver_displayView.cpp
  group Middlewares/TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m0/IAR8.x/: touchgfx_core.a
  group Middlewares/TouchGFX/target
    ../TouchGFX/target/: STM32TouchController.cpp TouchGFXDataReader.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
  group Middlewares/TouchGFX/target/generated
    ../TouchGFX/target/generated/: OSWrappers.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedDataReader.cpp TouchGFXGeneratedHAL.cpp
  group Middlewares/X-CUBE-SUB2/App
    ../Middlewares/X-CUBE-SUBG2/App/: app_x-cube-subg2.c
  group Middlewares/X-CUBE-SUB2/Target
    ../Middlewares/X-CUBE-SUBG2/Target/: s2lp_management.c
