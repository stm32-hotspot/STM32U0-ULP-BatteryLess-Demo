# Keil uVision project STM32U083RC-NUCLEO-GFX01M2.uvprojx, settings and files
target STM32U083RC-NUCLEO-GFX01M2 (6140001::V6.14.1::ARMCLANG)
  device: STM32U083RCTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.0.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32U083RC-NUCLEO-GFX01M2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U083xx
  c include: ../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Core/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\STM32U083RC-NUCLEO-GFX01M2.sct
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application/User/Core
    ../Core/Src/: MB1642DisplayDriver.c MB1642DataReader.c MB1642ButtonController.cpp main.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXDataReader.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp TouchGFXGeneratedDataReader.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_crc.c stm32u0xx_hal_crc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
software components: CMSIS:CORE 4.3.0
