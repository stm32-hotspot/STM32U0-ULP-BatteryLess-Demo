# IAR project STM32U083RC-NUCLEO-GFX01M2.ewp, settings and files
configuration STM32U083RC-NUCLEO-GFX01M2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083RC ST STM32U083RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_NUCLEO_64; USE_HAL_DRIVER; STM32U083xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../Drivers/BSP/STM32U0xx_Nucleo; ../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../Drivers/CMSIS/Include; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32U083RC-NUCLEO-GFX01M2.hex
  ILINK.IlinkOutputFile: STM32U083RC-NUCLEO-GFX01M2.out
  ILINK.IlinkIcfFile: stm32u083xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u083xx.s
  group Application/User/Core
    ../Core/Src/: MB1642DisplayDriver.c MB1642DataReader.c MB1642ButtonController.cpp main.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXDataReader.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp TouchGFXGeneratedDataReader.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_crc.c stm32u0xx_hal_crc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_crc.c stm32u0xx_hal_crc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
