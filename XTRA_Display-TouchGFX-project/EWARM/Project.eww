<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32U083RC-NUCLEO-GFX01M2.ewp</path>
  </project>
  <batchBuild />
</workspace>
