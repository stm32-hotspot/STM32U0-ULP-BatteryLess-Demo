# IAR project Data-Logger-and-Transmission-Module.ewp, settings and files
configuration Data-Logger-and-Transmission-Module (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083MC ST STM32U083MC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U083xx; USE_STM32U083C_DISCO_REVB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc; ../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\BSP\STM32U083C-DK; ..\Drivers\BSP\Components\Common; ..\Drivers\BSP\X-NUCLEO-S2868A2; ..\Drivers\CMSIS\Device\ST\STM32U0xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\STM32U0xx_HAL_Driver\Inc; ..\Middlewares\X-CUBE-SUBG2\App; ..\Middlewares\X-CUBE-SUBG2\Target; ..\Drivers\BSP\Components\S2LP; ..\Drivers\BSP\Components\S2LP\S2LP_Library\inc; ..\Drivers\BSP\Components\STTS22H
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Data-Logger-and-Transmission-Module.hex
  ILINK.IlinkOutputFile: Data-Logger-and-Transmission-Module.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_STM32u083xx.s
  group Application/User/Core
    ../Core/Src/: demo_pv.c main.c stm32u0xx_hal_msp.c stm32u0xx_it.c
  group Drivers/BSP/Components/S2LP
    ../Drivers/BSP/Components/S2LP/: s2lp.c
    ../Drivers/BSP/Components/S2LP/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/Components/STTS22H
    ../Drivers/BSP/Components/STTS22H/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STM32U083C-DK
    ../Drivers/BSP/STM32U083C-DK/: stm32u083c_discovery.c stm32u083c_discovery_bus.c stm32u083c_discovery_env_sensors.c stm32u083c_discovery_glass_lcd.c
  group Drivers/BSP/X-NUCLEO-S2868A2
    ../Drivers/BSP/X-NUCLEO-S2868A2/: s2868a2.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_i2c.c stm32u0xx_hal_i2c_ex.c stm32u0xx_hal_lcd.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_rtc.c stm32u0xx_hal_rtc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c stm32u0xx_ll_adc.c
  group Middlewares/X-CUBE-SUB2/App
    ../Middlewares/X-CUBE-SUBG2/App/: app_x-cube-subg2.c
  group Middlewares/X-CUBE-SUB2/Target
    ../Middlewares/X-CUBE-SUBG2/Target/: s2lp_management.c
