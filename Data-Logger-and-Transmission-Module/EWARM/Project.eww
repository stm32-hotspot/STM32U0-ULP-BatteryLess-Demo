<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Data-Logger-and-Transmission-Module.ewp</path>
    </project>
    <batchBuild />
</workspace>
